# Keil uVision project STM32F429_BSP.uvprojx, settings and files
target STM32F429_BSP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F429_BSP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\project;..\Hal;..\User;..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./: startup_stm32f429xx.s
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Hal
    ../Hal/: hal_uart.c hal_led.c hal_spi.c w25qxx.c at24cxx.c hal_i2c.c hal_sdio.c hal_internalflash.c hal_adc.c hal_tim.c
  group Drivers
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cec.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_sram.c stm32f4xx_hal_spi.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_sd.c stm32f4xx_hal_sai.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_qspi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pccard.c stm32f4xx_hal_nor.c stm32f4xx_hal_nand.c stm32f4xx_hal_mmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_lptim.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_irda.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2c.c stm32f4xx_hal_hcd.c stm32f4xx_hal_hash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash.c stm32f4xx_hal_exti.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_cryp.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_adc.c stm32f4xx_ll_usart.c stm32f4xx_ll_spi.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_gpio.c stm32f4xx_hal_uart.c
  group User
    ../User/: main.cpp stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f429_hal_system.c test.c
  group Fatfs
    ../Lib/: diskio.c ff.c ffsystem.c ffunicode.c
software components: CMSIS:CORE 4.3.0
